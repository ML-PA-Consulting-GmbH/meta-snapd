## conf/distro/m2cp-yocto-os.conf
```bitbake
DISTRO_NAME="m2cp-yocto-os"
DISTRO_VERSION="2.61.8"
SDK_VERSION="m2cp-yocto-os.2.61.8"
```
